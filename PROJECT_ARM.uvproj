# Keil uVision project PROJECT_ARM.uvproj, settings and files
target Simulator (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: PROJECT_ARM
  c define: Simulator
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Startup Code
    ./: SAM7.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: delay.c lcd.c main_code.c ds18b20.c one_wire.c
  group Documentation
    ./: Abstract.txt
target SAM7X Flash - ULINK (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: as above
  output: PROJECT_ARM +hex
  c define: Flash
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
target SAM7X RAM - ULINK (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: as above
  output: PROJECT_ARM
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x8000
  memory RVCT9: RAM 0x208000 size 0x8000
